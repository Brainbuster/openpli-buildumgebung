KV = "3.14.2"
SRCDATE = "20150204"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "98d7cab81d7795d8cdff7d1d1504c5ee"
SRC_URI[sha256sum] = "0e0d71d03ae1caaeb28ffe8377651f0123e72b998f172a66487e53d5a1cccfc4"
