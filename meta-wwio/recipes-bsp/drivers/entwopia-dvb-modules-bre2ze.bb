KV = "3.14.2"
SRCDATE = "20150721"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "6abdb613d0abc370ceb669e5680dc509"
SRC_URI[sha256sum] = "e3d953e12154d74844376d3b28e5a293eb02d45f521ccef8b220aa87aaff092c"
